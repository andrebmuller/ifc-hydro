Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: b3d1f3b5-c5e1-4f57-aea3-c74e6e495680, VersionGUID: 7327474e-0b04-46db-9891-2ea47f24128c, NumberOfSaves: 23], CoordinateReference [CoordinateBase: Shared Coordinates], ExchangeRequirement [BuildingService]
File name: MODELO HIDRAULICO.ifc
Time: 2026-01-14T13:57:00-03:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (ENU) - IFC 24.3.20.8

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m
Pset_SiteCommon - Reference: Informações do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 3
Pset_BuildingElementProxyCommon - Reference: Informações do projeto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informações do projeto; sets with these values: 2

# IfcBuildingStorey: Nível:INP-Level (3)
Pset_BuildingStoreyCommon - Reference: INP-Level
Name | LongName | Elevation (m)
01 Térreo | 01 Térreo | 0.5
02 Superior | 02 Superior | 3.75
03 Coberta | 03 Coberta | 6.75

# IfcDistributionPort (188)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection | SystemType | Group
Port_373240_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373282_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373240_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373280_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373282_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373280_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373286_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373286_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384365_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373342_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384399_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373342_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373365_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373352_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373365_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373352_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373396_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373396_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395177_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373816_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375499_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_373816_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377078_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375497_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375499_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375497_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375503_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375499_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375500_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_375500_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395172_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377171_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395176_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377171_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395180_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377207_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377211_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377207_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377218_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377209_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377211_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377209_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377215_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377211_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377212_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377212_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377602_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377367_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377497_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377367_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377395_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377495_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377497_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377495_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377501_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377497_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377498_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377498_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379596_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_377602_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379256_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379166_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379198_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379256_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379262_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379262_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379263_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379262_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379307_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379263_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384317_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379307_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379325_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379315_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379347_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379325_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_383715_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379385_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379389_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379398_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379566_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379398_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384301_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379444_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384313_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379444_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384317_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379477_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384301_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379477_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384311_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379566_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379597_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379596_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379597_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_379596_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_383643_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_383635_1 | SOURCEANDSINK
Port_383635_2 | SOURCEANDSINK
Port_383636_1 | SOURCEANDSINK
Port_383636_2 | SOURCEANDSINK
Port_383637_1 | SOURCEANDSINK
Port_383637_2 | SOURCEANDSINK
Port_383709_1 | SOURCEANDSINK
Port_383709_2 | SOURCEANDSINK
Port_383710_1 | SOURCEANDSINK
Port_383710_2 | SOURCEANDSINK
Port_383711_1 | SOURCEANDSINK
Port_383711_2 | SOURCEANDSINK
Port_383811_1 | SOURCEANDSINK
Port_383811_2 | SOURCEANDSINK
Port_383812_1 | SOURCEANDSINK
Port_383812_2 | SOURCEANDSINK
Port_383813_1 | SOURCEANDSINK
Port_383813_2 | SOURCEANDSINK
Port_383817_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395180_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_383870_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395176_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_383870_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395172_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384189_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384399_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384189_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384403_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384196_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384313_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384196_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384364_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384207_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384403_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384207_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394796_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384311_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384314_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384313_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384314_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384364_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384400_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384364_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384365_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384399_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384400_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384472_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394793_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384472_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394796_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384717_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394793_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_384717_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394571_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
InPort_394511_1 | SINK | DOMESTICCOLDWATER | AF 1
OutPort_394630_2 | SOURCE | DOMESTICCOLDWATER | AF 1
OutPort_394511_7 | SOURCE | SEWAGE
Port_394558_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394940_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394558_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394587_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394569_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394571_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394569_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394940_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394579_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394587_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394579_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394649_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394626_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394649_3 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394626_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394630_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394649_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394660_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394660_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_397357_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394940_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394951_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394951_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394970_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394964_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394970_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394964_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_394998_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395176_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_395177_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_397349_0 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_397357_2 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_397349_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1
Port_397383_1 | SOURCEANDSINK | DOMESTICCOLDWATER | AF 1

# IfcDistributionSystem: Água Fria, AF 1
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Água Fria

# IfcFlowTerminal: Adaptador_Mangueira_ Bucha_Reducao:Standard, Adaptador_Mangueira_ Bucha_Reducao:Standard:394512
In: 01 Térreo
Type - Material: <Unnamed>
Pset_EnvironmentalImpactIndicators - Reference: Standard

# IfcPipeFitting: Adaptador_Bolsa_Rosca_Registro_Soldável_Aninhado:20 mm - 1/2" (3)
In: 02 Superior
Type - Material: PVC Soldavel
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: 20 mm - 1/2"; sets with these values: 2
Name (Adaptador_Bolsa_Rosca_Registro_Soldável_Aninhado:20 mm - 1/2":...)
383636
383710
383812

# IfcPipeFitting: Adaptador_Bolsa_Rosca_Registro_Soldável_Aninhado:25 mm - 3/4" (3)
In: 02 Superior
Type - Material: PVC Soldavel
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: 25 mm - 3/4"; sets with these values: 2
Name (Adaptador_Bolsa_Rosca_Registro_Soldável_Aninhado:25 mm - 3/4":...)
383637
383711
383813

# IfcPipeFitting: Joelho_90_Bucha_Latao_Soldavel:Standard (12)
Type - PredefinedType: BEND; Material: PVC Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: AF 1
Name (Joelho_90_Bucha_Latao_Soldavel:Standard:...) | In
375503 | 02 Superior
377078 | 03 Coberta
377215 | 02 Superior
377218 | 03 Coberta
377395 | 03 Coberta
377501 | 02 Superior
379198 | 03 Coberta
379347 | 02 Superior
379389 | 02 Superior
394630 | 01 Térreo
394998 | 01 Térreo
397383 | 01 Térreo

# IfcPipeFitting: Joelho_Soldavel:Standard (19)
Type - PredefinedType: BEND; Material: PVC Soldavel
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: AF 1
Name (Joelho_Soldavel:Standard:...) | In
373282 | 03 Coberta
373286 | 03 Coberta
373365 | 03 Coberta
373396 | 03 Coberta
377602 | 03 Coberta
379325 | 02 Superior
379566 | 03 Coberta
384301 | 03 Coberta
384311 | 03 Coberta
384317 | 03 Coberta
384403 | 03 Coberta
394571 | 01 Térreo
394587 | 01 Térreo
394793 | 01 Térreo
394796 | 03 Coberta
394970 | 01 Térreo
395172 | 03 Coberta
395180 | 03 Coberta
397357 | 01 Térreo

# IfcPipeFitting: Te_Soldavel:Standard (11)
Type - PredefinedType: JUNCTION; Material: PVC Soldavel
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: AF 1
Name (Te_Soldavel:Standard:...) | In
375499 | 02 Superior
377211 | 02 Superior
377497 | 02 Superior
379262 | 02 Superior
379596 | 02 Superior
384313 | 03 Coberta
384364 | 03 Coberta
384399 | 03 Coberta
394649 | 01 Térreo
394940 | 01 Térreo
395176 | 02 Superior

# IfcPipeSegment: Tipos de tubos:PVC Soldável (45)
Type - PredefinedType: RIGIDSEGMENT
Pset_EnvironmentalImpactIndicators - Reference: PVC Soldável; sets with these values: 2
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.0004908 m2; NetCrossSectionArea: 0.0004908 m2
Group: AF 1
Name (Tipos de tubos:PVC Soldável:...) | In | Length (m) | OuterSurfaceArea (m2)
373240 | 03 Coberta | 0.621855 | 0.0488403
373280 | 03 Coberta | 0.92 | 0.0722566
373342 | 03 Coberta | 8.11958 | 0.63771
373352 | 03 Coberta | 1.69223 | 0.132907
373816 | 03 Coberta | 0.989838 | 0.0777417
375497 | 02 Superior | 0.337 | 0.0264679
375500 | 03 Coberta | 0.480566 | 0.0377435
377171 | 02 Superior | 0.2005 | 0.0157472
377207 | 03 Coberta | 0.839838 | 0.0659607
377209 | 02 Superior | 0.337 | 0.0264679
377212 | 03 Coberta | 0.569675 | 0.0447421
377367 | 03 Coberta | 0.339838 | 0.0266908
377495 | 02 Superior | 0.337 | 0.0264679
377498 | 03 Coberta | 1.05607 | 0.0829432
379166 | 03 Coberta | 0.835625 | 0.0656298
379256 | 03 Coberta | 0.3505 | 0.0275282
379263 | 03 Coberta | 2.1005 | 0.164973
379307 | 02 Superior | 0.151391 | 0.0118902
379315 | 02 Superior | 0.835625 | 0.0656298
379385 | 02 Superior | 0.835625 | 0.0656298
379398 | 03 Coberta | 2.515 | 0.197528
379444 | 03 Coberta | 0.638603 | 0.0501558
379477 | 03 Coberta | 0.731103 | 0.0574207
379597 | 03 Coberta | 0.1505 | 0.0118202
383643 | 02 Superior | 0.534625 | 0.0419893
383715 | 02 Superior | 0.149125 | 0.0117123
383817 | 03 Coberta | 0.149125 | 0.0117123
383870 | 03 Coberta | 0.3505 | 0.0275282
384189 | 03 Coberta | 0.186177 | 0.0146223
384196 | 03 Coberta | 1.73234 | 0.136057
384207 | 03 Coberta | 3.365 | 0.264286
384314 | 03 Coberta | 0.351391 | 0.0275982
384365 | 03 Coberta | 1.04404 | 0.0819989
384400 | 03 Coberta | 0.663103 | 0.05208
384472 | 01 Térreo | 4.54697 | 0.357118
384717 | 01 Térreo | 1.23821 | 0.0972485
394558 | 01 Térreo | 0.0685 | 0.00537998
394569 | 01 Térreo | 1.9505 | 0.153192
394579 | 01 Térreo | 0.827963 | 0.0650281
394626 | 01 Térreo | 0.187 | 0.0146869
394660 | 01 Térreo | 0.634859 | 0.0498617
394951 | 01 Térreo | 0.3505 | 0.0275282
394964 | 01 Térreo | 1.24406 | 0.0977081
395177 | 03 Coberta | 2.1005 | 0.164973
397349 | 01 Térreo | 0.0515 | 0.0040448

# IfcSanitaryTerminal: Maquina_Lavar_Roupa:Standard, Maquina_Lavar_Roupa:Standard:394511
In: 01 Térreo
Type - PredefinedType: USERDEFINED; Material: PVC Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: AF 1

# IfcValve: Base_Registro_Pressão_Bronze_Aninhado:3/4 (3)
In: 02 Superior
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: INPrediais
Pset_EnvironmentalImpactIndicators - Reference: 3/4; sets with these values: 2
Name (Base_Registro_Pressão_Bronze_Aninhado:3/4:...)
383635
383709
383811
