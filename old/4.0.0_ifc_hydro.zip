Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 7d083296-61e1-42d2-b961-062ad1c2ecb1, NumberOfSaves: 23], CoordinateReference [CoordinateBase: Coordenadas compartilhadas], ExchangeRequirement [BuildingService]
File name: 0001
Time: 2024-05-21T09:37:59-03:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (PTB) - IFC 24.1.11.26

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 m
Pset_SiteCommon - Reference: Informações do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 2
Pset_BuildingElementProxyCommon - Reference: Informações do projeto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informações do projeto; sets with these values: 2

# IfcBuildingStorey: Nível:8 mm Extremidade superior (2)
Pset_BuildingStoreyCommon - Reference: 8 mm Extremidade superior
Name | LongName | Elevation (m)
COORD - PAV. TÉRREO | COORD - PAV. TÉRREO | 0.4
COORD - LAJE | COORD - LAJE | 3.2

# IfcDistributionPort (55)
Description: Flow; PredefinedType: PIPE; SystemType: DOMESTICCOLDWATER
Name | FlowDirection | Group
OutPort_1226733_1 | SOURCE
OutPort_1226733_2 | SOURCE | Água fria doméstica 5
InPort_1236690_0 | SINK | Água fria doméstica 4
OutPort_1226733_3 | SOURCE | Água fria doméstica 4
OutPort_1226733_4 | SOURCE | Água fria doméstica 3
Port_1226733_5 | SOURCEANDSINK | Água fria doméstica 1
Port_1228056_1 | SOURCEANDSINK | Água fria doméstica 1
Port_1226733_6 | SOURCEANDSINK
Port_1226733_7 | SOURCEANDSINK
Port_1226733_8 | SOURCEANDSINK | Água fria doméstica 2
InPort_1226734_2 | SINK
Port_1228056_2 | SOURCEANDSINK | Água fria doméstica 1
InPort_1234498_0 | SINK | Água fria doméstica 4
OutPort_1234975_1 | SOURCE | Água fria doméstica 4
InPort_1234611_3 | SINK | Água fria doméstica 4
OutPort_1234498_1 | SOURCE | Água fria doméstica 4
InPort_1234508_1 | SINK | Água fria doméstica 4
OutPort_1236690_1 | SOURCE | Água fria doméstica 4
InPort_1234977_0 | SINK | Água fria doméstica 4
OutPort_1234508_2 | SOURCE | Água fria doméstica 4
Port_1234542_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234611_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234542_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234595_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234552_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1235154_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234552_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234597_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1234589_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234589_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234597_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234595_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1235156_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234611_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1234689_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234689_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234811_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234697_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1238403_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1234697_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234798_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234819_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1234798_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234811_3 | SOURCEANDSINK | Água fria doméstica 4
Port_1234811_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1234812_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234812_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1238403_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234817_0 | SOURCEANDSINK | Água fria doméstica 4
Port_1234819_1 | SOURCEANDSINK | Água fria doméstica 4
Port_1234817_1 | SOURCEANDSINK | Água fria doméstica 4
InPort_1234975_2 | SINK | Água fria doméstica 4
OutPort_1234977_1 | SOURCE | Água fria doméstica 4
Port_1235154_2 | SOURCEANDSINK | Água fria doméstica 4
Port_1235156_1 | SOURCEANDSINK | Água fria doméstica 4

# IfcDistributionSystem: Água fria doméstica (5)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Água fria doméstica
Name
Água fria doméstica 5
Água fria doméstica 4
Água fria doméstica 3
Água fria doméstica 1
Água fria doméstica 2

# IfcFlowTerminal: Tampa Caixa D_Agua - Agua Fria - MEP -Tigre:Tampa - 1000 L, Tampa Caixa D_Agua - Agua Fria - MEP -Tigre:Tampa - 1000 L:1236841
In: COORD - LAJE
Type - Material: PEMD Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Tampa - 1000 L

# IfcFlowTerminal: Torneira Boia - Agua Fria - MEP -Tigre:1/2", Torneira Boia - Agua Fria - MEP -Tigre:1/2":1226734
In: COORD - LAJE
Type - Material: PEMD Azul, Plastic
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: 1/2"

# IfcPipeFitting: Bucha de Reducao Curta - Agua Fria_Soldavel - MEP - Tigre:Standard, Bucha de Reducao Curta - Agua Fria_Soldavel - MEP - Tigre:Standard:1228056
In: COORD - LAJE
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.026 m; GrossCrossSectionArea: 0.000765661 m2; NetCrossSectionArea: 0.000765661 m2; OuterSurfaceArea: 0.00326726 m2
Group: Água fria doméstica 1

# IfcPipeFitting: Joelho 45_90 - Agua Fria_Soldavel - MEP - Tigre:Standard (2)
In: COORD - LAJE
Type - PredefinedType: BEND; Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: Água fria doméstica 4
Name (Joelho 45_90 - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1234508
1234595

# IfcPipeFitting: Joelho 90 com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard (3)
In: COORD - PAV. TÉRREO
Type - PredefinedType: EXIT; Material: PVC Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: Água fria doméstica 4
Name (Joelho 90 com Bucha de Latao - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1234597
1234819
1238403

# IfcPipeFitting: Te_Reducao - Agua Fria_Soldavel - MEP - Tigre:Standard (2)
In: COORD - LAJE
Type - PredefinedType: JUNCTION; Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Group: Água fria doméstica 4
Name (Te_Reducao - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1234611
1234811

# IfcPipeSegment: Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre (9)
In: COORD - LAJE
Type - PredefinedType: RIGIDSEGMENT
Pset_EnvironmentalImpactIndicators - Reference: PVC - Agua Fria - Tubo Soldável Tigre; sets with these values: 2
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.0004908 m2; NetCrossSectionArea: 0.0004908 m2
Group: Água fria doméstica 4
Name (Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre:...) | Length (m) | OuterSurfaceArea (m2)
1234498 | 0.870184 | 0.0683441
1234542 | 0.6962 | 0.0546794
1234552 | 0.959384 | 0.0753498
1234689 | 0.1182 | 0.00928341
1234798 | 0.6702 | 0.0526374
1234812 | 0.4188 | 0.0328925
1234977 | 1.66403 | 0.130693
1235156 | 0.167685 | 0.01317
1236690 | 0.548607 | 0.0430875

# IfcSanitaryTerminal: Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre, Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre:1234589
In: COORD - PAV. TÉRREO
Type - PredefinedType: SHOWER
Pset_EnvironmentalImpactIndicators - Reference: PVC - Agua Fria - Tubo Soldável Tigre; sets with these values: 2
Group: Água fria doméstica 4

# IfcSanitaryTerminal: Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre, Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre:1234697
In: COORD - PAV. TÉRREO
Type - PredefinedType: WASHHANDBASIN
Pset_EnvironmentalImpactIndicators - Reference: PVC - Agua Fria - Tubo Soldável Tigre; sets with these values: 2
Group: Água fria doméstica 4

# IfcSanitaryTerminal: Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre, Tipos de tubos:PVC - Agua Fria - Tubo Soldável Tigre:1234817
In: COORD - PAV. TÉRREO
Type - PredefinedType: WCSEAT
Pset_EnvironmentalImpactIndicators - Reference: PVC - Agua Fria - Tubo Soldável Tigre; sets with these values: 2
Group: Água fria doméstica 4

# IfcTank: Caixa D_Agua_Completa_2014 - Agua Fria - MEP -Tigre:Caixa com Tampa - 1000 L, Caixa D_Agua_Completa_2014 - Agua Fria - MEP -Tigre:Caixa com Tampa - 1000 L:1226733
In: COORD - LAJE
Type - PredefinedType: STORAGE; Material: PEMD Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Caixa com Tampa - 1000 L; sets with these values: 2
Group: Água fria doméstica 5; Água fria doméstica 4; Água fria doméstica 3; Água fria doméstica 1; Água fria doméstica 2

# IfcValve: Adaptador com Anel - Agua Fria_Soldavel - MEP - Tigre:Standard (2)
In: COORD - LAJE
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (Adaptador com Anel - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1226736
1227337

# IfcValve: Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard (3)
In: COORD - LAJE
Type - Material: Phenolic Resin, PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (Adaptador com Registro - Agua Fria_Soldavel - MEP - Tigre:Standard:...)
1226735
1227269
1227303

# IfcValve: Registro de Chuveiro - Agua Fria - MEP - Tigre:PVC Branco - 25 mm, Registro de Chuveiro - Agua Fria - MEP - Tigre:PVC Branco - 25 mm:1235154
In: COORD - LAJE
Type - PredefinedType: REGULATING; Material: PVC Branco_01
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: PVC Branco - 25 mm; sets with these values: 2
Group: Água fria doméstica 4

# IfcValve: Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Branco - 25 mm, Registro de Gaveta - Agua Fria - MEP - Tigre:PVC Branco - 25 mm:1234975
In: COORD - LAJE
Type - PredefinedType: ISOLATING; Material: PVC Branco_01
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_EnvironmentalImpactIndicators - Reference: PVC Branco - 25 mm; sets with these values: 2
Group: Água fria doméstica 4
